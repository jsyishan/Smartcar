# Keil uVision project SmartCar9th_ARM_Encoder.uvproj, settings and files
target SmartCar_ARM_Encoder (ARM-ADS)
  device: LPC1114/302 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SmartCar9th_ARM_Encoder +hex
  c flags: Optim=1
  c include: .\source\Hearders;.\startup
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./startup/: startup_LPC11xx.s
  group Control
    ./source/Control/: Arithmetic.c IRQHandler.c motor_control.c protect.c servo_control.c
  group Driver
    ./source/Driver/: common.c digital_sensor.c Init_Encoder.c Init_GPIO.c Init_motor.c Init_servo.c motor.c servo.c SystemInit.c test.c uart.c
  group Main
    ./source/: SmartCar6th.c
